options:
  parameters:
    generate_options: qt_gui
    id: Spectrum_Samples_Generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 824e6
    step: 0.01e9
    stop: 960e6
    value: '854000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sr
  states: {}
- name: sr
  id: variable_qtgui_range
  parameters:
    start: 32e3
    step: '100'
    stop: 5.88e6
    value: '5880000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '8972'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: bw
    fc: center_freq
    fftsize: '1024'
    type: complex
    ymax: '-70'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bw
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: '"addr=192.168.10.2"'
    gain0: '15'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', network_udp_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
