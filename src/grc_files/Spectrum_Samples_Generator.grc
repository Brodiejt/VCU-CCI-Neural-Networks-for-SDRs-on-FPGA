options:
  parameters:
    generate_options: qt_gui
    id: Spectrum_Samples_Generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 824e6
    step: 0.01e9
    stop: 960e6
    value: '854000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sr
  states: {}
- name: sr
  id: variable_qtgui_range
  parameters:
    start: 32e3
    step: '100'
    stop: 5.88e6
    value: '4880000'
  states: {}
- name: variable_rrc_filter_taps_1
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1.0'
    ntaps: 11*8
    samp_rate: samp_rate
    sym_rate: samp_rate/8
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: bw
    fc: center_freq
    fftsize: '1024'
    type: complex
    ymax: '-70'
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bw
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    clock_source0: internal
    dev_addr: '"addr=192.168.10.2"'
    gain0: '15'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', network_tcp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
